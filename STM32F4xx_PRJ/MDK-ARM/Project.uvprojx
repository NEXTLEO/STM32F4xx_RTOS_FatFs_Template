# Keil uVision project Project.uvprojx, settings and files
target STM32F4xx_PRJ (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F427IGHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: STM32F4xxFW +hex
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=2
  c define: USE_HAL_DRIVER STM32F427xx HSE_VALUE=16000000 LOG_RTT
  c include: ..\Inc;..\Src;..\..\Drivers\STM32F4xx_HAL_Driver\Src;..\..\Drivers\STM32F4xx_HAL_Driver\Inc;..\..\Middlewares\Third_Party\FatFs\src;..\..\Middlewares\Third_Party\FatFs\src\drivers;..\..\Drivers\HAL_MSP\TIM;..\..\Drivers\HAL_BSP\SD;..\..\Drivers\HAL_BSP\LED;..\..\Drivers\HAL_BSP\FILE;..\..\Drivers\HAL_BSP\log;..\..\Middlewares\SEGGER_RTT\RTT;..\..\Middlewares\SEGGER_RTT\Syscalls;..\..\Middlewares\Third_Party\FreeRTOS\Source\portable\MemMang;..\..\Middlewares\Third_Party\FreeRTOS\Source\portable\RVDS\ARM_CM4F;..\..\Middlewares\Third_Party\FreeRTOS\Source\CMSIS_RTOS;..\..\Middlewares\Third_Party\FreeRTOS\Source;..\..\Middlewares\Third_Party\FreeRTOS\Source\include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x60000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  link misc: --diag_suppress=L6329
  group Application/User
    ../Src/: main.c init.c stm32f4xx_it.c
    ../../Drivers/HAL_BSP/log/: log.c
  group Drivers/STM32F4xx_HAL_Driver
    ../../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_adc.c stm32f4xx_hal_cec.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_flash.c stm32f4xx_hal_gpio.c stm32f4xx_hal_i2c.c stm32f4xx_hal_iwdg.c stm32f4xx_hal_pwr.c stm32f4xx_hal_rtc.c stm32f4xx_hal_sd.c stm32f4xx_hal_sdram.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_uart.c stm32f4xx_hal_usart.c stm32f4xx_hal_wwdg.c stm32f4xx_hal_rcc.c stm32f4xx_hal.c stm32f4xx_ll_sdmmc.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_rcc_ex.c
  group Drivers/HAL_BSP
    ../../Drivers/HAL_BSP/LED/: hal_bsp_led.c
    ../../Drivers/HAL_BSP/SD/: hal_bsp_sd.c
    ../../Drivers/HAL_BSP/FILE/: hal_bsp_file.c
  group Drivers/HAL_MSP
    ../../Drivers/HAL_MSP/TIM/: hal_msp_tim.c
  group Middlewares/FatFs/Core
    ../../Middlewares/Third_Party/FatFs/src/: ff.c ff_gen_drv.c diskio.c
    ../../Middlewares/Third_Party/FatFs/src/option/: unicode.c
  group Middlewares/FatFs/Driver
    ../../Middlewares/Third_Party/FatFs/src/drivers/: sd_diskio.c
  group Middlewares/SEGGER_RTT
    ../../Middlewares/SEGGER_RTT/RTT/: SEGGER_RTT.c SEGGER_RTT_printf.c
    ../../Middlewares/SEGGER_RTT/Syscalls/: SEGGER_RTT_Syscalls_KEIL.c
  group Middlewares/FreeRTOS/CMSIS_RTOS
    ../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
  group Middlewares/FreeRTOS
    ../../Middlewares/Third_Party/FreeRTOS/Source/: list.c queue.c tasks.c timers.c
  group Middlewares/FreeRTOS/portable
    ../../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
    ../../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
  group Doc
    ../Doc/: version.txt readme.txt
software components: CMSIS:CORE 5.0.2, Device:Startup 2.6.0
